## boards/shields/keebq1/Kconfig.defconfig
```kconfig
if SHIELD_KEEBQ1

config ZMK_KEYBOARD_NAME
    default "keebq"

endif # SHIELD_KEEBQ1
```
